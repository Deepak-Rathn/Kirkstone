require lxc-image.inc
