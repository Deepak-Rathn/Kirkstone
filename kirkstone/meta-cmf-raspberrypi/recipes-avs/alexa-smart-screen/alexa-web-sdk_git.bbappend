SRC_URI_remove += "file://${RDKROOT}/downloads/AlexaSmartScreenVoiceChrome-1.1.0.tar;name=voicechrome;destsuffix=voicechrome"
SRC_URI += "https://artifactory.rdkcentral.com/artifactory/alexa/voice_chrome/1.1.0/AlexaSmartScreenVoiceChrome-1.1.0.tar;name=voicechrome;destsuffix=voicechrome"
