FILESEXTRAPATHS_prepend:="${THISDIR}/${PN}:"

SRC_URI_append = " file://CVE-2021-36369_dropbear_2020.81_fix.patch "
