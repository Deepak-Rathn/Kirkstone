FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://CVE-2020-27618_fix.patch \
           "
