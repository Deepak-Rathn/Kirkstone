# Placeholder: If your third-party app needs integration with rdk-logger,
# you can add configuration, default log levels, or package RDEPENDS here.
# Example (uncomment and adjust if needed):
# RDEPENDS:${PN} += "rdk-logger"
