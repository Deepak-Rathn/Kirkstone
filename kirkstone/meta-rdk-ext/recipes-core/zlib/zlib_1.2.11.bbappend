FILESEXTRAPATHS_prepend:="${THISDIR}/${PN}:"

SRC_URI += " file://CVE-2022-37434_fix.patch "

