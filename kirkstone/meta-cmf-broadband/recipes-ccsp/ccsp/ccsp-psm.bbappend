DEPENDS += "cjson"
LDFLAGS += "-lcjson"
PV_kirkstone = "${RDK_RELEASE}+git${SRCPV}"
