inherit coverity

LDFLAGS_remove = " -ldpp"
