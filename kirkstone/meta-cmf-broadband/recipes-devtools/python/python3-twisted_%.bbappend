RDEPENDS:${PN}-conch_remove_kirkstone_broadband = "${PYTHON_PN}-cryptography"
